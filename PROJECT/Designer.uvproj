# Keil uVision project Designer.uvproj, settings and files
target target (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Designer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\INC
  group USER
    ./USER/: main.c
  group INC
    ./INC/: 1602.h DS1302.h key.h
  group FLIB
    ./FLIB/: DS1302.c 1602.c key.c
